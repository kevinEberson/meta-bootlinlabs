SUMMARY = "Bootlin labs games"
inherit packagegroup

RDEPENDS:${PN} = "\
	ninvaders"
